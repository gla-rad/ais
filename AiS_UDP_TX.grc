options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: top_block
    output_language: python
    run_options: run
  states: {}

blocks:
- name: bit_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '326531'
  states: {}
- name: udp_port_1
  id: variable
  parameters:
    value: '8881'
  states: {}
- name: udp_port_2
  id: variable
  parameters:
    value: '8882'
  states: {}
- name: AISTX_Build_Input_Frame_0
  id: AISTX_Build_Input_Frame
  parameters:
    enable_NRZI: 'False'
    repeat: 'True'
  states: {}
- name: AISTX_Build_Input_Frame_0_0
  id: AISTX_Build_Input_Frame
  parameters:
    enable_NRZI: 'False'
    repeat: 'True'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-25000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '25000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.9'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.9'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'False'
    ipaddr: 0.0.0.0
    port: udp_port_1
    psize: '1024'
    type: byte
    vlen: '1'
  states: {}
- name: blocks_udp_source_0_0
  id: blocks_udp_source
  parameters:
    eof: 'False'
    ipaddr: 0.0.0.0
    port: udp_port_2
    psize: '1024'
    type: byte
    vlen: '1'
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.4'
    samples_per_symbol: int(samp_rate/bit_rate)
  states: {}
- name: digital_gmsk_mod_0_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.4'
    samples_per_symbol: int(samp_rate/bit_rate)
  states: {}
- name: note_0
  id: note
  parameters:
    note: nc -u localhost 8881
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: nc -u localhost 8882
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=24993a63
    bb_gain0: '20'
    bb_gain1: '20'
    corr1: '0'
    freq0: 162e6
    freq1: 100e6
    gain0: '10'
    gain1: '10'
    if_gain0: '20'
    if_gain1: '20'
    nchan: '2'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: uhd.tune_request_t(162000000, -25000)
    center_freq1: uhd.tune_request_t(162000000, 25000)
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: '10'
    gain1: '10'
    len_tag_name: ''
    lo_export1: 'False'
    lo_source1: internal
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    show_lo_controls: 'True'
    sync: sync
    type: fc32
  states: {}

connections:
- [AISTX_Build_Input_Frame_0, '0', digital_gmsk_mod_0, '0']
- [AISTX_Build_Input_Frame_0_0, '0', digital_gmsk_mod_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_const_vxx_0_1, '0', blocks_null_sink_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', blocks_null_sink_0, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', osmosdr_sink_0, '1']
- [blocks_multiply_const_vxx_0_1_0, '0', uhd_usrp_sink_0, '1']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_multiply_xx_0_0, '0', blocks_multiply_const_vxx_0_1_0, '0']
- [blocks_udp_source_0, '0', AISTX_Build_Input_Frame_0, '0']
- [blocks_udp_source_0_0, '0', AISTX_Build_Input_Frame_0_0, '0']
- [digital_gmsk_mod_0, '0', blocks_multiply_xx_0, '0']
- [digital_gmsk_mod_0_0, '0', blocks_multiply_xx_0_0, '0']

metadata:
  file_format: 1
